# Keil uVision project STM32L073RZT6.uvprojx, settings and files
target STM32L073RZT6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L073RZT6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx
  c misc: --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32L073RZT6\" -DSYSINFO_DEVICE_NAME=\"STM32L073RZT6\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.0.1\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Include;..\..\..\..\board\STM32L073RZ-Nucleo;..\..\..\..\kernel\rhino\core\include;..\..\..\..\include;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\platform\arch\arm\armv6m\armcc\m0plus;..\..\..\..\platform\mcu\stm32l0xx\src\STM32L073RZ-Nucleo\helloworld;..\..\..\include\hal;..\..\..\kernel\vcall\aos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group kernel/rhino/core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_fifo.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_obj_set.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_trace.c k_workqueue.c
  group platform\arch\arm\armv6m\armcc\m0plus
    ../../../../platform/arch/arm/armv6m/armcc/m0plus/: port_c.c port_s.s
  group platform\mcu\stm32l0xx\aos
    ../../../../platform/mcu/stm32l0xx/aos/: soc_impl.c
    ../../../../example/rhinorun/: rhinorun.c
  group platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Src
    ../../../../platform/mcu/stm32l0xx/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_cortex.c
  group platform\mcu\stm32l0xx\src\common
    ../../../../platform/mcu/stm32l0xx/src/common/: stm32l0xx_hal_msp.c system_stm32l0xx.c
  group platform\mcu\stm32l0xx\src\STM32L073RZ-Nucleo
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/: startup_stm32l073xx_keil.s
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/helloworld/: soc_init.c stm32l0xx_it.c
software components: CMSIS:CORE 4.1.0
